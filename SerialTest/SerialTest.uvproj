# Keil uVision project SerialTest.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8xC51/8xCL51 Philips
  cpu: IRAM(0 - 0x7F) IROM(0-0xFFF) CLOCK(33000000)
  output: Project2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../Project2/: TicTacToe.c
